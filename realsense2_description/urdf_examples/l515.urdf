Commit message: fix: l515

File: realsense2_description/urdf_examples/l515.urdf (robot description, URDF)
Before this commit: robot realsense2_camera, 5 links, 4 joints
Links:
- removed link base_link
Joints:
- removed joint camera_joint
